# Keil uVision project STM32_Example.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: STM32_Example +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDEARE\TIMER;..\HARDEARE\DS1302;..\HARDEARE\STMFLASH;..\HARDEARE\IIC;..\HARDEARE\max30205;..\HARDEARE\AMG8833;..\HARDEARE\HMIsend
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: main.c IO_init.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDEARE
    ../HARDEARE/TIMER/: timer.c
    ../HARDEARE/STMFLASH/: stmflash.c
    ../HARDEARE/IIC/: IIC.c
    ../HARDEARE/AMG8833/: AMG8833.c
    ../HARDEARE/HMIsend/: HMIsend.c
